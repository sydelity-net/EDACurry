.global VDD VCC
