// ============================================================================
// SPICE
// ============================================================================
.option post = 2
