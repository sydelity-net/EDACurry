//============================================================================
// Resistor (or RC Wire)
// Rxx N1 N2
//      [MOD[EL]=MNAME] [VAL] [[TC1=]T1] [[TC2=]T2] [[TC3=]T3]
//    + [AC=VAL|{EXPR}] [T[EMP]=VAL] [DTEMP=VAL] [M=VAL] [L=VAL] [W=VAL]
//    + [STATISTICAL=0|1] [KEEPRMIN] [NONOISE] [KF=VAL] [AF=VAL] [WEEXP=VAL]
//    + [LEEXP=VAL] [FEXP=VAL] [FMIN=VAL] [FMAX=VAL] [NBF=VAL]
//
//      [MOD[EL]=MNAME] VALUE={EXPR} [ACDERFUNC=0|1]
//    + [RESTORE_CAUSALITY=0|1] [[TC1=]T1] [[TC2=]T2] [[TC3=]T3] [AC=VAL]
//    + [T[EMP]=VAL] [DTEMP=VAL] [M=VAL] [STATISTICAL=0|1] [KEEPRMIN] [NONOISE]
//    + [KF=VAL] [AF=VAL] [WEEXP=VAL] [LEEXP=VAL] [FEXP=VAL] [FMIN=VAL]
//    + [FMAX=VAL] [NBF=VAL] [FIT=0|1] [CFMAX=VAL] [CDELF=VAL]
//
//      [[TC1=]T1] [[TC2=]T2] [[TC3=]T3] [AC=VAL] [T[EMP]=VAL]
//    + [DTEMP=VAL] [M=VAL] [KF=VAL] [AF=VAL] [WEEXP=VAL] [LEEXP=VAL]
//    + [FEXP=VAL] [FMIN=VAL] [FMAX=VAL] [NBF=VAL] [STATISTICAL=0|1]
//    + TABLE EXPR [KEEPRMIN] [NONOISE]
//
//      POLY VAL {COEF} [TC1=T1] [TC2=T2] [TC3=T3] [STATISTICAL=0|1]
// RC Wire
//      MNAME [[R=]VAL] [TC1=VAL] [TC2=VAL] [C=VAL] [CRATIO=VAL]
//    + [L=VAL] [W=VAL] [M=VAL] [T[EMP]=VAL] [DTEMP=VAL] [SCALE=VAL]
//    + [STATISTICAL=0|1]
//============================================================================
r1 1 2 res1
r2 1 2 res1
r3 1 3 res1
r4 1 2 res1 M=2
r5 n3 n4 3.3k
r6 n1 n2 rval
r7 1 2 value={2k*v(3,4)*i(v5)}
rg8 4 5 table v(p3n)=(0, 1e11) (1v, 1e3)
r9 1 2 value={50*sqrt(+(FREQ/10e6))}
r10 1 2 ac=3 value={2k * v(3,4) * i(v5)}
r11 3 4 value={50*sqrt(1+(FREQ/10e6))} tc1=0.001 tc2=0.004 tc3=0.003
r12 1 2 value={1k + 2k*v(1)} ACDERFUNC=1
r13 n1 n19 rmodel 2.5k
r1 n3 n4 mod1 tc1=0.001
r2 n1 n2 r rmodel tc1=0.05

// ============================================================================
// SPICE
// ============================================================================
// Resistors
R1 1 2 100
RC1 12 17 1K

// Semiconductor Resistors
RLOAD 2 10 10K
RMOD 3 7 RMODEL L=10u W=1u
